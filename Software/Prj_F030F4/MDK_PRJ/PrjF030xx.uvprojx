# Keil uVision project PrjF030xx.uvprojx, settings and files
target F030xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F03xx +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,xUSE_FULL_ASSERT
  c include: ..\CORE;..\CORE\include;..\CORE\Device;..\FWLib\inc;..\Utilities;..\User;..\User\ISR;..\User\Led;..\User\Uart
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group User
    ../User/: main.c
    ../User/ISR/: stm32f0xx_it.c
    ../User/Led/: led.c
    ../User/SD_ADC/: SD_ADC_Driver.c
  group Utilities
    ../Utilities/: delay.c
  group FWLib
    ../FWLib/src/: stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_usart.c
  group CORE
    ../CORE/Device/: startup_stm32f0xx.s system_stm32f0xx.c
software components: CMSIS:CORE 5.1.2
